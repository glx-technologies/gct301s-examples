# Keil uVision project blinky_systick.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: GCT301S SZGC
  pack: SZGC.GCT301S.1.0.8
  cpu: IROM(0x00000000,0x20000) IROM2(0x10000000,0x8000) IRAM(0x20000000,0x1800) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: blinky_systick
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
